Commit message: rviz rotated nicely

File: src/rviz_custom/urdf/moonbot.urdf (robot description, URDF)
Before this commit: robot Moonbot1, 14 links, 13 joints
Joints:
- joint moonbot_attachment: origin xyz=0 0 0 rpy=0 0 0 -> xyz=0 0 0 rpy=0 0 0.785398
